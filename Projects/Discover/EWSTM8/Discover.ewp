# IAR project Discover.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3U STM8S103K3U
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Discover.srec
  ILINK.IlinkOutputFile: Discover.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: main.h stm8s_conf.h stm8s_it.h
  group Include Files/FWLib
    ../../../Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_exti.h stm8s_gpio.h stm8s_tim4.h
  group Source Files
    ../src/: main.c stm8s_it.c
  group Source Files/FWLib
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_exti.c stm8s_gpio.c stm8s_tim4.c
